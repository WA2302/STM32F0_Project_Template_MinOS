# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Public;..\App;..\..\..\MinOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Output\Project.sct
  link misc: --diag_suppress=L6329
  group App
    ../: main.c stm32f0xx_it.c
    ../App/: App_include.h App_Demo1.c App_Demo2.c App_Demo3.c
  group MinOS
    ../../../MinOS/: minos.c
  group Public
    ../../../Public/: Pub_Include.h Pub_CPID_Delta.cpp Pub_CSoftPWM.cpp Pub_CTimer.cpp
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_pwr.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_adc.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_rtc.c stm32f0xx_gpio.c stm32f0xx_dbgmcu.c stm32f0xx_crc.c stm32f0xx_wwdg.c stm32f0xx_can.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_crs.c stm32f0xx_comp.c stm32f0xx_dac.c stm32f0xx_cec.c
  group CMSIS
    ../: system_stm32f0xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s startup_stm32f030xc.s startup_stm32f070x6.s startup_stm32f091.s startup_stm32f070xb.s startup_stm32f031.s startup_stm32f042.s startup_stm32f030.s startup_stm32f051.s
  group Doc
    ../: README.md
